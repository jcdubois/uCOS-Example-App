# IAR project Ping.ewp, settings and files
configuration library (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G2 NXP MCIMX6G2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\..; ..\..\OS3; ..\..\..\..\BSP\MCIMX6UL-EVK; ..\..\..\..\..\Micrium\Software\uC-CPU; ..\..\..\..\..\Micrium\Software\uC-CPU\ARM-Cortex-A\ARMv7-A\IAR; ..\..\..\..\..\Micrium\Software\uC-LIB; ..\..\..\..\..\Micrium\Software\uCOS-III; ..\..\..\..\..\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\Micrium\Software\uCOS-III\Ports\ARM-Cortex-A\ARMv7-A\IAR; ..\..\..\..\..\Micrium\Software\uC-TCPIP; ..\..\..\..\..\Micrium\Software\uC-Common; ..\..\..\..\..\Micrium\Software\uC-DHCPc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ping.srec
  ILINK.IlinkOutputFile: Ping.out
  ILINK.IlinkIcfFile: ..\..\..\..\BSP\Startup\MCIMX6G2\IAR\ddr.icf
  ILINK.IlinkAdditionalLibs: Ping.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration source (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..; ..\..\OS3; ..\..\..\..\BSP\MCIMX6UL-EVK; ..\..\..\..\..\Micrium\Software\uC-CPU; ..\..\..\..\..\Micrium\Software\uC-CPU\ARM-Cortex-A\ARMv7-A\IAR; ..\..\..\..\..\Micrium\Software\uC-LIB; ..\..\..\..\..\Micrium\Software\uCOS-III; ..\..\..\..\..\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\Micrium\Software\uCOS-III\Ports\ARM-Cortex-A\ARMv7-A; ..\..\..\..\..\Micrium\Software\uCOS-III\Ports\ARM-Cortex-A\ARMv7-A\IAR; ..\..\..\..\..\Micrium\Software\uC-TCPIP; ..\..\..\..\..\Micrium\Software\uC-Common; ..\..\..\..\..\Micrium\Software\uC-DHCPc
configuration libgen (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  group Micrium/Software/uC/Common
    ../../../../../Micrium/Software/uC-Common/: common.h common_err.h
  group Micrium/Software/uC/Common/KAL
    ../../../../../Micrium/Software/uC-Common/KAL/: kal.h
  group Micrium/Software/uC/Common/KAL/uCOS-III
    ../../../../../Micrium/Software/uC-Common/KAL/uCOS-III/: kal.c
  group Micrium/Software/uC/CPU
    ../../../../../Micrium/Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group Micrium/Software/uC/CPU/ARM-Cortex-A/ARMv7-A/IAR
    ../../../../../Micrium/Software/uC-CPU/ARM-Cortex-A/ARMv7-A/IAR/: cpu.h cpu_a.asm
  group Micrium/Software/uC/DHCPc/OS/uCOS-III
    ../../../../../Micrium/Software/uC-DHCPc/OS/uCOS-III/: dhcp-c_os.c
  group Micrium/Software/uC/DHCPc/Source
    ../../../../../Micrium/Software/uC-DHCPc/Source/: dhcp-c.c dhcp-c.h
  group Micrium/Software/uC/LIB
    ../../../../../Micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium/Software/uC/OS-III/Ports/ARM-Cortex-A/ARMv7-A
    ../../../../../Micrium/Software/uCOS-III/Ports/ARM-Cortex-A/ARMv7-A/: os_cpu_c.c
  group Micrium/Software/uC/OS-III/Ports/ARM-Cortex-A/ARMv7-A/IAR
    ../../../../../Micrium/Software/uCOS-III/Ports/ARM-Cortex-A/ARMv7-A/IAR/: os_cpu.h os_cpu_a_vfp-d16.asm os_cpu_a_vfp-d32.asm os_cpu_a_vfp-none.asm
  group Micrium/Software/uC/OS-III/Source
    ../../../../../Micrium/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group Micrium/Software/uC/TCPIP/Dev/Ether/MACNet
    ../../../../../Micrium/Software/uC-TCPIP/Dev/Ether/MACNet/: net_dev_macnet.c net_dev_macnet.h
  group Micrium/Software/uC/TCPIP/Dev/Ether/PHY/KSZ8081RNB
    ../../../../../Micrium/Software/uC-TCPIP/Dev/Ether/PHY/KSZ8081RNB/: net_phy_ksz8081rnb.c net_phy_ksz8081rnb.h
  group Micrium/Software/uC/TCPIP/FS
    ../../../../../Micrium/Software/uC-TCPIP/FS/: net_fs.h
  group Micrium/Software/uC/TCPIP/IF
    ../../../../../Micrium/Software/uC-TCPIP/IF/: net_if.c net_if.h net_if_802x.c net_if_802x.h net_if_ether.c net_if_ether.h net_if_loopback.c net_if_loopback.h net_if_wifi.c net_if_wifi.h
  group Micrium/Software/uC/TCPIP/IP/IPv4
    ../../../../../Micrium/Software/uC-TCPIP/IP/IPv4/: net_arp.c net_arp.h net_icmpv4.c net_icmpv4.h net_igmp.c net_igmp.h net_ipv4.c net_ipv4.h
  group Micrium/Software/uC/TCPIP/IP/IPv6
    ../../../../../Micrium/Software/uC-TCPIP/IP/IPv6/: net_dad.c net_dad.h net_icmpv6.c net_icmpv6.h net_ipv6.c net_ipv6.h net_mldp.c net_mldp.h net_ndp.c net_ndp.h
  group Micrium/Software/uC/TCPIP/Source
    ../../../../../Micrium/Software/uC-TCPIP/Source/: net.c net.h net_app.c net_app.h net_ascii.c net_ascii.h net_bsd.c net_bsd.h net_buf.c net_buf.h net_cache.c net_cache.h net_cfg_net.h net_conn.c net_conn.h net_ctr.c net_ctr.h net_def.h net_err.h net_icmp.c net_icmp.h net_ip.c net_ip.h net_mgr.c net_mgr.h net_sock.c net_sock.h net_stat.c net_stat.h net_tcp.c net_tcp.h net_tmr.c net_tmr.h net_type.h net_udp.c net_udp.h net_util.c net_util.h
  group NXP/BSP/Interrupts
    ../../../../BSP/Interrupts/: bsp_int_armv7a_gicv2.c
  group NXP/BSP/MCIMX6UL-EVK
    ../../../../BSP/MCIMX6UL-EVK/: bsp_ccm.c bsp_ccm.h bsp_cpu.c bsp_gpio.c bsp_gpio.h bsp_int.h bsp_iomux.c bsp_iomux.h bsp_net_macnet.c bsp_net_macnet.h bsp_os.c bsp_os.h bsp_sys.c bsp_sys.h
  group NXP/BSP/Startup/MCIMX6G2/IAR
    ../../../../BSP/Startup/MCIMX6G2/IAR/: cstartup.s ddr.icf
  group NXP/MCIMX6UL-EVK/Ping
    ../../: app_cfg.h app_tcpip.c app_tcpip.h cpu_cfg.h dhcp-c_cfg.h lib_cfg.h net_cfg.c net_cfg.h net_dev_cfg.c net_dev_cfg.h
  group NXP/MCIMX6UL-EVK/Ping/OS3
    ../: main.c os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
